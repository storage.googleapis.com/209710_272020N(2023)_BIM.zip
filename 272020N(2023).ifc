Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-06-14T17:22:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 14 17:22:06 2023 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\759ee022-3bab-4bb7-b5d6-2821236c801b\35751f2b-d18e-41af-a485-a42323f7dc47\ifc * Database version: 5507 * Database creation date: Wed Jun 14 17:22:05 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 14 17:22:05 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 14 17:22:05 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowController: 272020N Hand shower, d 110 mm, 272020N(2023):272020N Hand shower, d 110 mm:343417
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 50.1 mm; NominalHeight: 257.2 mm; NominalWidth: 109.8 mm
Type - General - Author: BIMStone; BIMObjectName: 272020N(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - EAN Number: 6414150099489; EN Standard: EN1112; ETIM Class Number: EC010161 Hand shower; Noise Class 02ls: I (ISO 3822); UNSPSC Class Number: 30181803 Hand held shower unit; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/272020N; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/272020N; 3D View: https://static.oras.com/AR/272020N; Catalog Drawing URL: http://static.oras.com/catdrw/272020N; Dimension Drawing URL: http://static.oras.com/dimdrw/272020N; FDV Document URL: http://www.oras.com/datasheet/272020N/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/272020N; Group: Hand shower; Installation and Maintenance Guide URL: http://static.oras.com/manual/272020N; Interactive AR View URL: https://static.oras.com/AR/272020N; Manufacturer: Oras; Market: Denmark;Estonia;Finland;International;Lithuania;Latvia;Norway;Poland;Sweden;Ukraine; Mobile Product Information URL: http://mpi.oras.com/272020N; Model: 272020N Hand shower, d 110 mm; Name_en: 272020N Hand shower, d 110 mm; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 272020N; Product Family: Oras Optima; Product Image URL: http://static.oras.com/image/272020N; Product URL: http://static.oras.com/272020N; Technical DataSheet URL: http://www.oras.com/datasheet/272020N/en; Type Name: 272020N Hand shower, d 110 mm; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Connection Size: G1/2; Flow Rate At 300kPa With Flow Reducers: 0.000706293 m3/s; Hand Shower Size: Ø110; Max. Hot Water Supply: 65 kg/K/s3; Shower Parts: Anti limescale technology (easy to clean); Shower Spray: Normal;Massage;Rain; Shower Spray Number: 3 shower sprays; Surface treatment: Chrome; Working Pressure: 50 - 500 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 272020N(2023); Features: n/a; Finish: Polished; Grade: n/a; Material: Composite; ModelNumber: n/a; ModelReference: 272020N; Name: 272020N Hand shower, d 110 mm; ReplacementCost: n/a; Shape: Sculptured; Size: 95 x 60 x 245 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0466152 m2; Volume: 0.00141422 m3
Identity Data - Mark: 19
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 272020N(2023): 272020N Hand shower, d 110 mm; Family and Type: 272020N(2023): 272020N Hand shower, d 110 mm; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 272020N(2023): 272020N Hand shower, d 110 mm; Type Id: 272020N(2023): 272020N Hand shower, d 110 mm; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
